# Keil uVision project mp3.uvproj, settings and files
target MP3 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mp3 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\User;.\User\calendar;.\User\lcd;.\User\sdcard;.\User\nor_flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./: startup_stm32f10x_hd.s
  group Libraries
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c delay.c eeprom.c lib.c key.c explorer.c RTX_Confg.c
    ./User/lcd/: setting.c
  group Lcd
    ./User/lcd/: ASC16.c tft_lcd.c backLight.c touch.c
    ./User/sdcard/: sdio.c
  group Fs
    ./User/sdcard/: diskio.c ff.c sdcard.c cc936.c
  group Image
    ./User/: bmpDecode.c photo.c
  group Calendar
    ./User/calendar/: calendar.c
    ./User/: time.c
  group Music
    ./User/: vs1003.c music.c
  group Book
    ./User/: book.c
